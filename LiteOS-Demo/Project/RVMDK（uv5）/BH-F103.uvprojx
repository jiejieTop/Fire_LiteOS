# Keil uVision project BH-F103.uvprojx, settings and files
target Fire_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_LiteOS +hex
  c flags: Optim=2 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS\Include;..\..\liteos\cmsis;..\..\liteos\cmsis\1.0;..\..\liteos\cmsis\2.0;..\..\liteos\kernel\include;..\..\liteos\kernel\base\include;..\..\liteos\kernel\extended\include;..\..\liteos\arch\arm\arm-m\include;..\..\liteos\arch\arm\arm-m\cortex-m3;..\..\User\los_config;..\..\User\Bsp\Led;..\..\User\Bsp\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Bsp/usart/: bsp_usart.c
    ../../User/Bsp/Led/: bsp_led.c
  group DOC
    ../../Doc/: readme.txt
  group liteos/cmsis
    ../../liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../liteos/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../liteos/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../liteos/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../liteos/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../liteos/kernel/base/mem/membox/: los_membox.c
    ../../liteos/kernel/base/misc/: los_misc.c
    ../../liteos/kernel/base/om/: los_err.c
    ../../liteos/kernel/: los_init.c
    ../../liteos/kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../liteos/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../../liteos/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group los_config
    ../../User/los_config/: los_builddef.h los_printf.h target_config.h
